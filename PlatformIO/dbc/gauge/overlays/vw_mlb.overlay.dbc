VERSION ""

NS_ :

BS_:

BU_:

CM_ "can2gauge overlay for opendbc vw_mlb.dbc (docs/CAN_DBC_plan.md, docs/8HP_research.md section 2.1): Audi A6/A7 C7, A8 D4, Q5 8R drivetrain CAN with the ZF 8HP (AL551). Only BA_ and VAL_ lines, merged by tools/dbc/dbc_tool.py. Values match lib/CANLine decodeVagMlb.";

BA_DEF_ SG_ "GaugeKey" STRING ;
BA_DEF_ SG_ "GaugePriority" INT 0 9;
BA_DEF_ "GaugeBusSpeed" INT 0 1000000;
BA_DEF_ BO_ "GaugeCheck" STRING ;
BA_DEF_DEF_ "GaugeKey" "";
BA_DEF_DEF_ "GaugePriority" 0;
BA_DEF_DEF_ "GaugeBusSpeed" 500000;
BA_DEF_DEF_ "GaugeCheck" "";

BA_ "GaugeBusSpeed" 500000;
BA_ "GaugeKey" SG_ 261 MO_Drehzahl_01 "rpm";
BA_ "GaugeKey" SG_ 261 MO_Fahrpedalrohwert_01 "pedal";
BA_ "GaugeKey" SG_ 256 ESP_v_Signal "speed";
BA_ "GaugeKey" SG_ 1600 MO_Kuehlmittel_Temp "coolant";
BA_ "GaugeKey" SG_ 1719 KBI_Inhalt_Tank "fuel";
BA_ "GaugeKey" SG_ 1719 KBI_Aussen_Temp_gef "ambient";
BA_ "GaugeKey" SG_ 258 GE_Zielgang "gear";
BA_ "GaugeKey" SG_ 258 GE_Waehlhebel "selector";
BA_ "GaugeKey" SG_ 258 GE_Eingangsdrehz "inputRpm";
BA_ "GaugeKey" SG_ 130 GE_Schaltvorgang "shifting";
BA_ "GaugeKey" SG_ 130 GE_Status_Kupplung "lockup";
BA_ "GaugeKey" SG_ 1089 GE_Sumpftemperatur "gboxTemp";
BA_ "GaugeCheck" BO_ 1600 "MO_Kuehlmittel_Temp -40 140";

VAL_ 258 GE_Zielgang 0 "N" 1 "1" 2 "2" 3 "3" 4 "4" 5 "5" 6 "6" 7 "7" 8 "R" 11 "8" 12 "9" 14 "Undefined" 15 "Error" ;
VAL_ 258 GE_Waehlhebel 0 "Undefined" 1 "Init" 5 "P" 6 "R" 7 "N" 8 "D" 9 "S" 10 "E" 13 "M" 14 "M" ;
VAL_ 258 GE_Eingangsdrehz 16382 "Init" 16383 "Error" ;
VAL_ 130 GE_Schaltvorgang 0 "0" 1 "1" ;
VAL_ 130 GE_Status_Kupplung 0 "0" 1 "1" 2 "2" 3 "Error" ;
VAL_ 1089 GE_Sumpftemperatur 255 "Error" ;
