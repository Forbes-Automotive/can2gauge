VERSION ""

NS_ :

BS_:

BU_:

CM_ "can2gauge overlay for opendbc vw_mqb.dbc (docs/CAN_DBC_plan.md). Only BA_ and VAL_ lines: tools/dbc/dbc_tool.py merges them into the gauge's copy, so opendbc's file is never edited. Signal names are opendbc's own; the tool renames them for the English copy. Values match the hand-written decoder in lib/CANLine (decodeVagMqb) so the two can be logged side by side.";

BA_DEF_ SG_ "GaugeKey" STRING ;
BA_DEF_ SG_ "GaugePriority" INT 0 9;
BA_DEF_ "GaugeBusSpeed" INT 0 1000000;
BA_DEF_ BO_ "GaugeCheck" STRING ;
BA_DEF_DEF_ "GaugeKey" "";
BA_DEF_DEF_ "GaugePriority" 0;
BA_DEF_DEF_ "GaugeBusSpeed" 500000;
BA_DEF_DEF_ "GaugeCheck" "";

BA_ "GaugeBusSpeed" 500000;
BA_ "GaugeKey" SG_ 168 MO_Drehzahl_01 "rpm";
BA_ "GaugeKey" SG_ 253 ESP_v_Signal "speed";
BA_ "GaugeKey" SG_ 289 MO_Fahrpedalrohwert_01 "pedal";
BA_ "GaugeKey" SG_ 1600 MO_Ansaugluft_Temp "iat";
BA_ "GaugeKey" SG_ 1600 MO_Kuehlmittel_Temp "coolant";
BA_ "GaugeKey" SG_ 1719 KBI_Inhalt_Tank "fuel";
BA_ "GaugeKey" SG_ 1719 KBI_Aussen_Temp_gef "ambient";
BA_ "GaugeKey" SG_ 173 GE_Fahrstufe "selector";
BA_ "GaugeKey" SG_ 173 GE_Zielgang "gear";
BA_ "GaugeKey" SG_ 173 GE_Schaltablauf "shifting";
BA_ "GaugeKey" SG_ 173 GE_Status_Kraftschluss "lockup";
BA_ "GaugeKey" SG_ 968 GE_Sumpftemperatur "gboxTemp";
BA_ "GaugeKey" SG_ 301 GE_Eingangsdrehz "inputRpm";
BA_ "GaugeCheck" BO_ 1600 "MO_Kuehlmittel_Temp -40 140";

VAL_ 173 GE_Fahrstufe 0 "Intermediate" 1 "Init" 5 "P" 6 "R" 7 "N" 8 "D" 9 "S" 10 "E" 13 "M" 14 "M" 15 "Error" ;
VAL_ 173 GE_Zielgang 0 "N" 1 "1" 2 "2" 3 "3" 4 "4" 5 "5" 6 "6" 7 "7" 8 "R" 11 "8" 12 "9" 13 "10" 14 "Undefined" 15 "Error" ;
VAL_ 173 GE_Schaltablauf 0 "0" 1 "1" 2 "1" 3 "1" ;
VAL_ 173 GE_Status_Kraftschluss 0 "0" 1 "0" 2 "1" 3 "0" 4 "2" 5 "2" 6 "Error" 7 "Error" ;
VAL_ 968 GE_Sumpftemperatur 255 "Error" ;
VAL_ 301 GE_Eingangsdrehz 16382 "Init" 16383 "Error" ;
